Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement [Architecture], Option [IfcExportBaseQuantities: Off], Option [IfcExportElementOnOffAndFrozenLayers: On], Option [IfcExplodeExternalReferences: Off], Option [IfcTesselateBSplineCurvesAndSurfaces: Off], Option [IfcExportSweptSolidAsBRep: Off], Option [IfcExportProfileCenterOfGravity: Off], Option [IfcExportMultiPlyElementsAsAggregated: Off], Option [IfcExportTesselation: 0.000000], Option [IfcCreateUniqueGuidForBlocks: On], Option [IfcCreateUniqueGuidForXrefs: On]
File name: D:\\Eigene Dateien\\Desktop\\OPO_00_Peka_02\\NeuBlock\\OPO_50.694.23.ifc
Time: 2025-11-08T21:21:39
Author: Undefined
Organization: Undefined
Written by: BricsCAD BIM 25.1.07
Made in: BricsCAD BIM 25.1.07
Authorization: Undefined

# IfcSite, Standort
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuilding, Standort
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm
