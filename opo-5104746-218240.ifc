Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement [Architecture], Option [IfcExportBaseQuantities: Off], Option [IfcExportElementOnOffAndFrozenLayers: On], Option [IfcExplodeExternalReferences: Off], Option [IfcTesselateBSplineCurvesAndSurfaces: Off], Option [IfcExportSweptSolidAsBRep: Off], Option [IfcExportProfileCenterOfGravity: Off], Option [IfcExportMultiPlyElementsAsAggregated: Off], Option [IfcExportTesselation: 0.000000], Option [IfcCreateUniqueGuidForBlocks: On], Option [IfcCreateUniqueGuidForXrefs: On]
File name: D:\\Eigene Dateien\\Desktop\\03\\NeuBlock\\OPO_51.047.46_volu_3d.ifc
Time: 2026-03-17T14:40:56
Author: Undefined
Organization: Undefined
Written by: BricsCAD BIM 25.1.07
Made in: BricsCAD BIM 25.1.07
Authorization: Undefined

# IfcSite, Standort
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuilding, Standort
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm
